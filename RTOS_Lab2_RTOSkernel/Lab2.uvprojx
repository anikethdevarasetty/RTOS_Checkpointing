# Keil uVision project Lab2.uvprojx, settings and files
target Lab2 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab2
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Lab2.c TCB.h
    ../RTOS_Labs_common/: OS.c ST7735.c eDisk.c efile.c osasm.s UART0int.c ADC.c FIFOsimple.c ff.c integer.h ffconf.h heap.c
    ../inc/: LaunchPad.c PLL.c ADCSWTrigger.c ADCT0ATrigger.c LPF.c WTimer0A.c cr4_fft_64_stm32.s IRDistance.c Timer5A.c Timer5A.h Timer0A.c Timer0A.h Timer1A.c Timer1A.h Timer2A.c Timer2A.h Timer3A.c Timer3A.h Timer4A.c Timer4A.h
software components: CMSIS:CORE 5.6.0
